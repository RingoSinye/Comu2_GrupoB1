options:
  parameters:
    generate_options: qt_gui
    id: triceratops
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (1,1,1)
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class blk (gr.sync_block):

      	def __init__(self) : # only default arguments here
      		gr.sync_block.__init__(
      		self ,
      		name ='Acumulador', # will show up in GRC
      		in_sig = [np.float32],
      		out_sig = [np.float32]
      		)
      		
      	def work (self , input_items , output_items ):

      		x = input_items[0] # Senal de entrada .
      		y0 = output_items[0] # Senal acumulada
      		limit= x[:2]
      		y0[:] = np.cumsum(limit)
      		return len(y0)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\nclass Blk(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name='e_Diff',  # Nombre que aparecerá en GRC\n            in_sig=[np.float32],\n            out_sig=[np.float32]\n        )\n        self.acum_anterior = 0\n\n    def work(self, input_items, output_items):\n        x = input_items[0]  # Señal de entrada\n        y0 = output_items[0]  # Señal acumulada diferencial\n        N = len(x)\n        diff = np.cumsum(x) - self.acum_anterior\n        self.acum_anterior = diff[N - 1]\n        y0[:] = diff\n        return len(y0)\n\n"
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}

connections:
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', epy_block_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
